# Keil uVision project FromA-Z.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FromA-Z
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: STM32F10x.s STM32_Init.c
  group MainFiles
    ./: main.c
